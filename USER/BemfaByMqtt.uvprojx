# Keil uVision project BemfaByMqtt.uvprojx, settings and files
target BemfaByMqtt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\USER;..\CORE;..\STLIB\inc;..\SYS;..\HARDWARE\delay;..\HARDWARE\DHT11;..\HARDWARE\usart;..\HARDWARE\timer;..\HARDWARE\mqtt;..\HARDWARE\U8g2;..\HARDWARE\led;..\HARDWARE\OLED_IIC(V2.0)
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group SYS
    ../SYS/: sys.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/mqtt/: mqtt.c pushdata.c wifi.c
    ../HARDWARE/timer/: timer2.c timer3.c timer4.c
    ../HARDWARE/usart/: usart1.c usart2.c
    ../HARDWARE/OLED_IIC(V2.0)/: oled.c
